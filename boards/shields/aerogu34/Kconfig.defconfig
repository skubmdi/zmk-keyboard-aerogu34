## boards/shields/aerogu34/Kconfig.defconfig
```kconfig
if SHIELD_AEROGU34_LEFT || SHIELD_AEROGU34_RIGHT

config ZMK_SPLIT
    default y

config NFCT_PINS_AS_GPIOS
    default y

endif
```
